## Kconfig
```kconfig
# Minimal Kconfig so Zephyr recognizes this module
menu "User config (zmk-config-mysplit)"
endmenu
```
